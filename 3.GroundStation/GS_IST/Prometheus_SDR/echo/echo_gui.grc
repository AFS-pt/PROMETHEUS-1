options:
  parameters:
    generate_options: qt_gui
    id: echo_gui
    output_language: python
  states: {}

blocks:
- name: Att_dB
  id: variable
  parameters:
    value: '0'
  states: {}
- name: bw
  id: variable
  parameters:
    comment: Bandwidth
    value: '125000'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: '436567500'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '434000000'
  states: {}
- name: cr
  id: variable
  parameters:
    comment: |-
      Coding
      Rate
    value: '4'
  states: {}
- name: frame_period
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '255'
  states: {}
- name: samp_rate_rx
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: samp_rate_tx
  id: variable
  parameters:
    value: 250000*4
  states: {}
- name: sf
  id: variable
  parameters:
    comment: |-
      Spreading 
      Factor
    value: '9'
  states: {}
- name: soft_decoding
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: variable_tag_object_0
  id: variable_tag_object
  parameters:
    key: pmt.intern("key")
    offset: '0'
    src: pmt.intern("src")
    value: pmt.intern("value")
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**((Att_dB)/20)
    minoutbuf: '10000000'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import pmt
      import time

      textboxValue = ""

      class my_sync_block(gr.sync_block):
          """
          reads input from a message port
          outputs text
          """
          def __init__(self):
              gr.sync_block.__init__(self,
                  name = "Echo Silencer",
                  in_sig = None,
                  out_sig = [np.float32])
              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('enable'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

          def handle_msg(self, msg):
              global textboxValue

              textboxValue = pmt.symbol_to_string (msg)
              # print (textboxValue)
          
          def work(self, input_items, output_items):
              global textboxValue

              # get length of string
              _len = len(textboxValue)
              if (_len > 0):
                  # terminate with LF
                  textboxValue += "\n"
                  _len += 1
                  # store elements in output array
                  for x in range(_len):
                      output_items[0][x] = ord(textboxValue[x])
                  textboxValue = ""
                  self.message_port_pub(pmt.intern('enable'), pmt.to_pmt(False))

                  time.sleep(2)
                  self.message_port_pub(pmt.intern('enable'), pmt.to_pmt(True))

                  return (_len)
              else:
                  return (0)
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '250000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: center_freq
    samplerate: samp_rate_tx
    type: fc32
    uri: plutoIP
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '250000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: center_freq
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'False'
    samplerate: samp_rate_rx
    type: fc32
    uri: plutoIP
  states: {}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: 'True'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'False'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    center_freq: int(center_freq)
    impl_head: impl_head
    os_factor: int(samp_rate_rx/bw)
    sf: sf
    show_log_port: 'False'
    sync_word: '18'
  states: {}
- name: lora_sdr_gray_demap_0
  id: lora_sdr_gray_demap
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: pay_len
    print_header: 'True'
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    bw: bw
    cr: cr
    ldro: '2'
    sf: sf
  states: {}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: int(bw/2)
    frame_zero_padd: int(20*2**sf*samp_rate_tx/bw)
    minoutbuf: '10000000'
    samp_rate: samp_rate_tx
    sf: sf
    sync_words: '0x12'
  states: {}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'False'
    source_type: message_strobe
  states: {}
- name: plutoIP
  id: parameter
  parameters:
    label: Pluto IP
    type: str
    value: ip:192.168.2.1
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    type: string
  states: {state: disabled}
- name: qtgui_edit_box_msg_1
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    type: string
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: bw
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: bw
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_2
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_tx*10
    fc: center_freq
    fftsize: '1024'
    rate: '1000'
    type: complex
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', iio_pluto_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_sink_x_0, '0']
- [blocks_selector_0, '0', lora_sdr_frame_sync_0, '0']
- [epy_block_0, '0', blocks_null_sink_0, '0']
- [epy_block_0, enable, blocks_selector_0, en]
- [iio_pluto_source_0, '0', blocks_selector_0, '0']
- [iio_pluto_source_0, '0', qtgui_sink_x_1, '0']
- [iio_pluto_source_0, '0', qtgui_sink_x_2, '0']
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_crc_verif_0, msg, epy_block_0, msg_in]
- [lora_sdr_crc_verif_0, msg, lora_sdr_whitening_0, msg]
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_gray_demap_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_frame_sync_0, frame_info]
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_demap_0, '0']
- [lora_sdr_modulate_0, '0', blocks_multiply_const_vxx_0, '0']
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']
- [qtgui_edit_box_msg_1, msg, lora_sdr_whitening_0, msg]
- [zeromq_sub_msg_source_0, out, lora_sdr_whitening_0, msg]

metadata:
  file_format: 1
